# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FS1003A_freeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\APL;..\FML;..\HAL;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\CORE;..\USMART;..\HAL\LCD;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\EMWIN\GUI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APL
    ../APL/: main.c stm32f4xx_it.c system_stm32f4xx.c test_task.c voltage_task.c rtc_task.c recheck_task.c
  group FML
    ../FML/: asc2bcd.c crc.c display.c fatfs.c fsm.c message.c protocol_fs.c serial.c gui_lcd.c
  group HAL
    ../HAL/: adc.c buzzer.c dma.c gpio.c key.c motor.c pwm.c rtc.c sdio_sdcard.c timer.c
    ../HAL/LCD/: ILI9486.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group DSP_Lib
    ../FWLIB/CMSIS/Include/: arm_math.h
    ../FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group README
    ../: readme.txt
